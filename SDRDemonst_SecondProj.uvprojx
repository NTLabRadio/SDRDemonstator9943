# Keil uVision project SDRDemonst_SecondProj.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SDRDemonst_SecondProj
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X,TARGET_DMR,DEBUG_DEFINE_TRUE_AS_1,DEBUG_CHANGE_INC_FROM_INITIAL_SDR_PROJECT,DEBUG_REM_MISSING_FUNCS_FROM_INITIAL_SDR_PROJECT,DEBUG_TEST_LOAD_FI_CMX7262
  c include: .\CMSIS\Include;.\StdPeriph\inc;.\StdPeriph\templates
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./SDRDemon/DMR/: mainDMR.c
  group STDPeriph
    ./StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./StdPeriph/templates/: stm32f10x_it.h
  group Drivers/SDR
    ./SDRDemon/DMR/: cmx7161.c CMX7262.c mmi_dmr.c radio.c
    ./SDRDemon/Common/: stm32f10x_it.c stm32f10x_sdr.c
    ./SDRDemon/MMI/: mmi.c
software components: Device:Startup 1.0.0
